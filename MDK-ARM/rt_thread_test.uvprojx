# Keil uVision project rt_thread_test.uvprojx, settings and files
target rt_thread_test (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: rt_thread_test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F1XX_HD,USE_HAL_DRIVER,STM32F103xB
  c include: ../RT-Thread; ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/RealThread_RTOS/include/; ../Middlewares/Third_Party/RealThread_RTOS/bsp/_template/cubemx_config; ../Middlewares/Third_Party/RealThread_RTOS/finsh/; ../Middlewares/Third_Party/RealThread_RTOS/components/finsh; ..\Drivers\STM32F1xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ./: app_rt_thread.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/RT-Thread/RTOS/kernel
    ../Middlewares/Third_Party/RealThread_RTOS/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
    ../Middlewares/Third_Party/RealThread_RTOS/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../Middlewares/Third_Party/RealThread_RTOS/bsp/_template/cubemx_config/: board.c
  group Middlewares/RT-Thread/RTOS/shell
    ../Middlewares/Third_Party/RealThread_RTOS/components/finsh/: cmd.c finsh_port.c msh.c shell.c
  group Middlewares/RT-Thread/RTOS/device
    ../Middlewares/Third_Party/RealThread_RTOS/components/device/: device.c
software components: CMSIS:CORE 4.3.0
